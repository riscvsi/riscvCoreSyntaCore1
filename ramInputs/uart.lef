###############################################################
#  Generated by:      Cadence Innovus 21.10-p004_1
#  OS:                Linux x86_64(Host ID localhost.localdomain)
#  Generated on:      Fri Feb  3 11:39:12 2023
#  Design:            uart
#  Command:           write_lef_abstract uart.lef -top_layer 9 -stripe_pins
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO uart
  CLASS BLOCK ;
  SIZE 57.600000 BY 56.050000 ;
  FOREIGN uart 0.000000 0.000000 ;
  ORIGIN 0 0 ;
  SYMMETRY X Y R90 ;
  PIN sys_clk
    DIRECTION INPUT ;
    USE SIGNAL ;
  END sys_clk
  PIN sys_rst
    DIRECTION INPUT ;
    USE SIGNAL ;
  END sys_rst
  PIN csr_a[13]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[13]
  PIN csr_a[12]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[12]
  PIN csr_a[11]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[11]
  PIN csr_a[10]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[10]
  PIN csr_a[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[9]
  PIN csr_a[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[8]
  PIN csr_a[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[7]
  PIN csr_a[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[6]
  PIN csr_a[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[5]
  PIN csr_a[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[4]
  PIN csr_a[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[3]
  PIN csr_a[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[2]
  PIN csr_a[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[1]
  PIN csr_a[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_a[0]
  PIN csr_we
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_we
  PIN csr_di[31]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[31]
  PIN csr_di[30]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[30]
  PIN csr_di[29]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[29]
  PIN csr_di[28]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[28]
  PIN csr_di[27]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[27]
  PIN csr_di[26]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[26]
  PIN csr_di[25]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[25]
  PIN csr_di[24]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[24]
  PIN csr_di[23]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[23]
  PIN csr_di[22]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[22]
  PIN csr_di[21]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[21]
  PIN csr_di[20]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[20]
  PIN csr_di[19]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[19]
  PIN csr_di[18]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[18]
  PIN csr_di[17]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[17]
  PIN csr_di[16]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[16]
  PIN csr_di[15]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[15]
  PIN csr_di[14]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[14]
  PIN csr_di[13]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[13]
  PIN csr_di[12]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[12]
  PIN csr_di[11]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[11]
  PIN csr_di[10]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[10]
  PIN csr_di[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[9]
  PIN csr_di[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[8]
  PIN csr_di[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[7]
  PIN csr_di[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[6]
  PIN csr_di[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[5]
  PIN csr_di[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[4]
  PIN csr_di[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[3]
  PIN csr_di[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[2]
  PIN csr_di[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[1]
  PIN csr_di[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END csr_di[0]
  PIN csr_do[31]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[31]
  PIN csr_do[30]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[30]
  PIN csr_do[29]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[29]
  PIN csr_do[28]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[28]
  PIN csr_do[27]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[27]
  PIN csr_do[26]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[26]
  PIN csr_do[25]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[25]
  PIN csr_do[24]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[24]
  PIN csr_do[23]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[23]
  PIN csr_do[22]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[22]
  PIN csr_do[21]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[21]
  PIN csr_do[20]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[20]
  PIN csr_do[19]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[19]
  PIN csr_do[18]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[18]
  PIN csr_do[17]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[17]
  PIN csr_do[16]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[16]
  PIN csr_do[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[15]
  PIN csr_do[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[14]
  PIN csr_do[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[13]
  PIN csr_do[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[12]
  PIN csr_do[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[11]
  PIN csr_do[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[10]
  PIN csr_do[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[9]
  PIN csr_do[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[8]
  PIN csr_do[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[7]
  PIN csr_do[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[6]
  PIN csr_do[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[5]
  PIN csr_do[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[4]
  PIN csr_do[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[3]
  PIN csr_do[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[2]
  PIN csr_do[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[1]
  PIN csr_do[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END csr_do[0]
  PIN rx_irq
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END rx_irq
  PIN tx_irq
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END tx_irq
  PIN uart_rx
    DIRECTION INPUT ;
    USE SIGNAL ;
  END uart_rx
  PIN uart_tx
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END uart_tx
  OBS
    LAYER Metal1 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal2 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal3 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal4 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal5 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal6 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal7 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal8 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
    LAYER Metal9 ;
      RECT 0.000000 0.000000 57.600000 56.050000 ;
  END
END uart

END LIBRARY
