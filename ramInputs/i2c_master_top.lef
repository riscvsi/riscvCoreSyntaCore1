###############################################################
#  Generated by:      Cadence Innovus 21.10-p004_1
#  OS:                Linux x86_64(Host ID localhost.localdomain)
#  Generated on:      Fri Feb  3 11:26:16 2023
#  Design:            i2c_master_top
#  Command:           write_lef_abstract i2c_master_top.lef -top_layer 9 -stripe_pins
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO i2c_master_top
  CLASS BLOCK ;
  SIZE 73.600000 BY 73.150000 ;
  FOREIGN i2c_master_top 0.000000 0.000000 ;
  ORIGIN 0 0 ;
  SYMMETRY X Y R90 ;
  PIN wb_clk_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_clk_i
  PIN wb_rst_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_rst_i
  PIN arst_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END arst_i
  PIN wb_adr_i[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_adr_i[2]
  PIN wb_adr_i[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_adr_i[1]
  PIN wb_adr_i[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_adr_i[0]
  PIN wb_dat_i[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[7]
  PIN wb_dat_i[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[6]
  PIN wb_dat_i[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[5]
  PIN wb_dat_i[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[4]
  PIN wb_dat_i[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[3]
  PIN wb_dat_i[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[2]
  PIN wb_dat_i[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[1]
  PIN wb_dat_i[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_dat_i[0]
  PIN wb_dat_o[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[7]
  PIN wb_dat_o[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[6]
  PIN wb_dat_o[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[5]
  PIN wb_dat_o[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[4]
  PIN wb_dat_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[3]
  PIN wb_dat_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[2]
  PIN wb_dat_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[1]
  PIN wb_dat_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_dat_o[0]
  PIN wb_we_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_we_i
  PIN wb_stb_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_stb_i
  PIN wb_cyc_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END wb_cyc_i
  PIN wb_ack_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_ack_o
  PIN wb_inta_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END wb_inta_o
  PIN scl_pad_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END scl_pad_i
  PIN scl_pad_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END scl_pad_o
  PIN scl_padoen_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END scl_padoen_o
  PIN sda_pad_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END sda_pad_i
  PIN sda_pad_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END sda_pad_o
  PIN sda_padoen_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END sda_padoen_o
  OBS
    LAYER Metal1 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal2 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal3 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal4 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal5 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal6 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal7 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal8 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
    LAYER Metal9 ;
      RECT 0.000000 0.000000 73.600000 73.150000 ;
  END
END i2c_master_top

END LIBRARY
